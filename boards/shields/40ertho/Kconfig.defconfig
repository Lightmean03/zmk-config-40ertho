## boards/shields/40ertho/Kconfig.defconfig
```kconfig
if SHIELD_40ERTHO

config ZMK_KEYBOARD_NAME
    default "40ertho"

config ZMK_STUDIO
    default y

endif
```
